# Keil uVision project Final.uvprojx, settings and files
target Final (6190000::V6.19::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Final +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c include: ./..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Code
    ./: lab.c ReedSW.c Switches.c startup.s ReedSW.h Switches.h DPS310.c display.c Heartbeat.c
    ../inc/: PLL.c ST7735.c UART.c Unified_Port_Init.c LaunchPad.c LED.c Timer0A.c Timer4A.c Timer2A.c ADCSWTrigger.c ADCSWTrigger.h
    ../lib/RGB/: RGB.c
  group Documentation
    ./: README.md
